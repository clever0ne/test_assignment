# Keil uVision project project_for_keil_5.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dummy +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB, USE_FULL_ASSERT, USE_STDPERIPH_DRIVER, STM32F10X_MD, USE_STM32_P103, HSE_VALUE=8000000
  c misc: --c99
  c include: .\src\cmsis;.\src;.\src\mcu_support_package\inc;.\src\spl\inc;.\src\spl;.\src\usb;.\src\usb\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\stack_protection.sct
  group main
    ./src/main/: main.c led.c timer.c thermometer.c one_wire.c usb.c button.c crc.c
  group mcu_support_package
    ./src/mcu_support_package/: system_stm32f10x.c
    ./src/mcu_support_package/arm/: startup_stm32f103xb.s
  group spl
    ./src/spl/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_dma.c
  group usb
    ./src/usb/src/: usb_core.c usb_desc.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c
